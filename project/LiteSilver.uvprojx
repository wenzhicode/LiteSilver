# Keil uVision project LiteSilver.uvprojx, settings and files
target LiteSilver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F103KBU MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LiteSilver +hex
  AfterMake: fromelf --bin !L -o .\BIN\Bootloader_F103.bin
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,F103_N_VERSION,ARM_MATH_CM3
  c misc: --diag_suppress=111,177,188,1565
  c include: ..\src\vcp;..\src\sensors;..\src\mavlink;..\src\mavlink\configurator;..\src\math;..\src\flight;..\src\log;..\src\drivers;..\src\config;..\lib\MM32F103\HAL_lib\inc;..\lib\MM32F103\Include;..\src\scheduler;..\src\battery;..\src\rx;..\src\osd;..\src\battery;..\src\failsafe
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: main.c
  group config
    ../src/config/: config.h defines.h targets.h
  group flight
    ../src/flight/: angle_pid.c imu.c pid.c stick_vector.c control.c
  group log
    ../src/log/: blackbox_encoding.c blackbox.c
  group osd
    ../src/osd/: osd.c item.c
  group startup
    ../src/startup/: system_MM32F103.c startup_MM32F103.s
  group sensors
    ../src/sensors/: mpu6500.c spl06001.c
  group rx
    ../src/rx/: rx.c rx_serial_sbus.c rx_serial_dsm.c rx_spi.c rx_spi_frskyd.c rx_spi_frskyx.c rx_bayang.c
  group vcp
    ../src/vcp/: msp.c ctrlitem.c ctrlusb.c usbprop.c usbreg.c serial_4way.c serial_4way_avrootloader.c configure.c
  group drivers
    ../src/drivers/: adc.c bus_i2c.c bus_softspi.c bus_spi.c dshot.c serial_uart.c serial_usb.c sys.c time.c misc_gpio.c cc2500.c flash.c flash_io.c rgb_led.c led.c xn297.c
  group lib
    ../lib/MM32F103/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group math
    ../src/math/: arm_fft_bin_data.c filter_iir.c filter_lpf.c maths.c util.c streambuf.c filter_pt1.c filter_biquad.c filter.cpp IIR_filter.c
  group battery
    ../src/battery/: battery.c
  group scheduler
    ../src/scheduler/: scheduler.c task.c
  group failsafe
    ../src/failsafe/: failsafe.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
